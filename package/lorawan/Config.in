## package/lorawan/Config.in
```kconfig
config BR2_PACKAGE_LORAWAN
	bool "lorawan"
	help
		lorawan and lora examples for Waveshare hats
```
